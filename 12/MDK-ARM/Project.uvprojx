# Keil uVision project Project.uvprojx, settings and files
target LR_TRAIN (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: SW_KFB
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L476xx,USE_HAL_DRIVER
  c misc: --C99
  c include: ..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\Drivers\STM32L4xx_HAL_Driver\Inc;..\Drivers\EEPROM\Core;..\Drivers\EEPROM\Porting\STM32L4;..\inc\board;..\inc\common;..\inc\mcu;..\inc;..\inc\board\sensors;..\inc\board\lcd;..\app;..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    ../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l476xx.s
  group Drivers/HAL_Drivers
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c
  group app
    ../app/: app.c main.c
    ./: flash_.c flash_.h
  group src/board
    ../src/board/: key.c sensors_test.c lorawan_node_driver.c
  group src/board/sensors
    ../src/board/sensors/: hdc1000.c max7q.c mma8451.c mpl3115.c opt3001.c
  group src/mcu
    ../src/mcu/: dma.c gpio.c i2c.c rtc.c stm32l4xx_hal_msp.c stm32l4xx_it.c tim.c usart.c
  group src/common
    ../src/common/: common.c
  group src/board/lcd
    ../src/board/lcd/: ST7789v.c XPT2046.c
